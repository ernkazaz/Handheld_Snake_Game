# Keil uVision project Snake_Project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Snake_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Accelerometer.c main.c I2C.c Nokia5110.c PWM.c ADC.c ADC_Read.s Accelerometer.h ADC.h Game.h I2C.h Nokia5110.h PWM.h Game.c Buzzer.h Buzzer.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
